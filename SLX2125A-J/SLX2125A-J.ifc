Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-08-23T16:39:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 23 16:39:40 2023 * Host: ZILBY3SGS3 * Database: C:\Users\SMalaya\AppData\Local\Temp\be762656-132c-4c59-9a45-0345e491cd14\a2944947-a5e9-4bda-9582-4975ecab65b3\ifc * Database version: 5507 * Database creation date: Wed Aug 23 16:39:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 23 16:39:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 23 16:39:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: SLX2125A-J_Just_Sink_Drop-In:SLX2125A-J, SLX2125A-J_Just_Sink_Drop-In:SLX2125A-J:763156
In: Level 1
Type - Material: 304 Stainless Steel, Stainless Steel
Type - Pset_DistributionFlowElementCommon - Reference: SLX2125A-J
Type - Pset_ElectricalDeviceCommon - IP_Code: n/a; InsulationStandardClass: n/a
Type - Pset_ElementShading - Color: 304 Stainless Steel
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Name: Sink_SLX2125A-J; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: SLX2125A-J
Material: Stainless Steel
Pset_DistributionFlowElementCommon - sets with these values: 2
